<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/rei/sampleAR2300IQ/test_stellarstation_file.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>ncols</key><value>30</value></param>
<param><key>nrows</key><value>30</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>stellarstation_bitstream_source</key>
<param><key>id</key><value>stellarstation_bitstream_source_0</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>satellite_id</key><value>"76"</value></param>
<param><key>key_path</key><value>/home/rei/Downloads/stellarstation-private-key-amateur.json</value></param>
<param><key>api_url</key><value>"api.stellarstation.com"</value></param>
<param><key>stream_id</key><value>""</value></param>
</block>
<connection><source_block_id>stellarstation_bitstream_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>stellarstation_bitstream_source_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
