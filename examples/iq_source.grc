<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>112500</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/rei/sampleAR2300IQ/test_stellarstation_file.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>stellarstation_iq_source</key>
<param><key>id</key><value>stellarstation_iq_source_0_0</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>satellite_id</key><value>"76"</value></param>
<param><key>key</key><value>/home/rei/Downloads/stellarstation-private-key-amateur.json</value></param>
<param><key>api_url</key><value>"api.stellarstation.com"</value></param>
<param><key>stream_id</key><value>""</value></param>
</block>
<connection><source_block_id>stellarstation_iq_source_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>stellarstation_iq_source_0_0</source_block_id><sink_block_id>qtgui_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
