<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_pdu_filter</key>
<param><key>id</key><value>blocks_pdu_filter_0</value></param>
<param><key>comment</key><value>BITSTREAM</value></param>
<param><key>invert</key><value>False</value></param>
<param><key>k</key><value>pmt.intern("FRAMING")</value></param>
<param><key>v</key><value>pmt.from_uint64(0)</value></param>
</block>
<block>
<key>blocks_pdu_filter</key>
<param><key>id</key><value>blocks_pdu_filter_0_0</value></param>
<param><key>comment</key><value>IQ</value></param>
<param><key>invert</key><value>False</value></param>
<param><key>k</key><value>pmt.intern("FRAMING")</value></param>
<param><key>v</key><value>pmt.from_uint64(2)</value></param>
</block>
<block>
<key>blocks_pdu_filter</key>
<param><key>id</key><value>blocks_pdu_filter_0_1</value></param>
<param><key>comment</key><value>AX25</value></param>
<param><key>invert</key><value>False</value></param>
<param><key>k</key><value>pmt.intern("FRAMING")</value></param>
<param><key>v</key><value>pmt.from_uint64(1)</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_1_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_1</value></param>
<param><key>ncols</key><value>100</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>stellarstation_api_source</key>
<param><key>id</key><value>stellarstation_api_source_0</value></param>
<param><key>root_cert_path</key><value></value></param>
<param><key>satellite_id</key><value>"1"</value></param>
<param><key>key</key><value>/home/rei/Downloads/stellarstation-private-key-amateur.json</value></param>
<param><key>api_url</key><value>"api.stellarstation.com"</value></param>
<param><key>stream_id</key><value>""</value></param>
</block>
<block>
<key>stellarstation_pdu_to_stream</key>
<param><key>id</key><value>stellarstation_pdu_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>stellarstation_pdu_to_stream</key>
<param><key>id</key><value>stellarstation_pdu_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_pdu_filter_0</source_block_id><sink_block_id>stellarstation_pdu_to_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>blocks_pdu_filter_0_0</source_block_id><sink_block_id>stellarstation_pdu_to_stream_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>blocks_pdu_filter_0_1</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>stellarstation_api_source_0</source_block_id><sink_block_id>blocks_pdu_filter_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>stellarstation_api_source_0</source_block_id><sink_block_id>blocks_pdu_filter_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>stellarstation_api_source_0</source_block_id><sink_block_id>blocks_pdu_filter_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>stellarstation_pdu_to_stream_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>stellarstation_pdu_to_stream_0_0</source_block_id><sink_block_id>qtgui_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
